# Keil uVision project test1.uvprojx, settings and files
target STM32F446RE (6190000::V6.19::.\ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=4
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./: main.c
  group os
    ./: osKernel.c osKernel.h osKernel.s osCfg.h
  group drivers
    ./: STK.c STK.h
  group utils
    ./: bitmath.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
